# Keil uVision project LLW_Project.uvprojx, settings and files
target Challenge10Sec (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Challenge10Sec +hex
  AfterMake: "C:\Keil\ARM\ARMCC\bin\fromelf.exe" --bin -o  ..\out\Game.bin ..\Output\Challenge10Sec.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\src\STM32Lib\CMSIS\CM3\CoreSupport;..\src\STM32Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\src\STM32Lib\STM32F10x_StdPeriph_Driver\inc;..\src\Lib;..\src\FreeRTOS\Source\include;..\src\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\SRC\LCD;..\SRC;..\SRC\User;..\SRC\FRAM
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../src/: main.c stm32f10x_it.c
    ../SRC/User/: TaskKey.c TaskDisplay.c TaskGsm.c
  group HAL
    ../SRC/User/: Set.c Key.c Game.c HardwareInit.c
    ../SRC/FRAM/: FM24C04.c
    ../SRC/MT/: MT_random.c
    ../SRC/LCD/: TFT32.c
  group HardwareLib
    ../SRC/User/: GPIO.c IIC.c USART.c
    ../src/User/: RCC.c TIM.c NVIC.c
  group CRC16
    ../SRC/CRC16/: CRC16.c
  group FreeRTOS
    ../src/FreeRTOS/Source/: list.c queue.c tasks.c
    ../src/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../src/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group StdPeriph_Driver
    ../src/STM32Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    ../SRC/STM32Lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_i2c.c stm32f10x_dma.c
  group MDK_ARM
    ../src/STM32Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../src/STM32Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../src/STM32Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Application
    ../src/Application/: application.txt
software components: CMSIS:CORE 5.0.1
